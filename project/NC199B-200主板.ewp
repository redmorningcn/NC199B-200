# IAR project NC199B-200主板.ewp, settings and files
configuration Flash (ARM, debug)
  General.OGChipSelectEditMenu: STM32F107xC ST STM32F107xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\source\config; ..\source\task; ..\source\user; ..\source\Software\OSAL\OS; ..\source\Software\OSAL\Ports; ..\source\driver; ..\source\Software\uC-LIB; ..\source\Software\uC-CPU; ..\source\Software\uC-CPU\ARM-Cortex-M3\IAR; ..\source\Software\uCOS-III\Ports\ARM-Cortex-M3\Generic\IAR; ..\source\Software\uCOS-III\Source; ..\source\Software\EvalBoards\Micrium\uC-Eval-STM32F107\BSP\IAR; ..\source\Software\EvalBoards\Micrium\uC-Eval-STM32F107\BSP\ST\STM32\inc; ..\source\Software\EvalBoards\Micrium\uC-Eval-STM32F107\BSP\OS\uCOS-III; ..\source\Software\EvalBoards\Micrium\uC-Eval-STM32F107\BSP; ..\source\Software\uC-MB\Cfg\Template; ..\source\Software\uC-MB\OS\uCOS-III; ..\source\Software\uC-MB\Ports\STM32\STM32F103\IAR; ..\source\Software\uC-MB\Source; ..\source\driver
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: NC199B-200主板.bin
  ILINK.IlinkOutputFile: OS.out
  ILINK.IlinkIcfFile: ..\source\Software\EvalBoards\Micrium\uC-Eval-STM32F107\BSP\IAR\STM32_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration app_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; APP_RELEASE
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\source\config; ..\source\task; ..\source\user; ..\source\Software\OSAL\OS; ..\source\Software\OSAL\Ports; ..\source\driver; ..\source\Software\uC-LIB; ..\source\Software\uC-CPU; ..\source\Software\uC-CPU\ARM-Cortex-M3\IAR; ..\source\Software\uCOS-III\Ports\ARM-Cortex-M3\Generic\IAR; ..\source\Software\uCOS-III\Source; ..\source\Software\EvalBoards\Micrium\uC-Eval-STM32F107\BSP\IAR; ..\source\Software\EvalBoards\Micrium\uC-Eval-STM32F107\BSP\ST\STM32\inc; ..\source\Software\EvalBoards\Micrium\uC-Eval-STM32F107\BSP\OS\uCOS-III; ..\source\Software\EvalBoards\Micrium\uC-Eval-STM32F107\BSP; ..\source\Software\uC-MB\Cfg\Template; ..\source\Software\uC-MB\OS\uCOS-III; ..\source\Software\uC-MB\Ports\STM32\STM32F103\IAR; ..\source\Software\uC-MB\Source
  OBJCOPY.OOCOutputFile: NC210-200处理板.bin
  ILINK.IlinkIcfFile: ..\source\Software\EvalBoards\Micrium\uC-Eval-STM32F107\BSP\IAR\STM32_FLASH_app_realse.icf
  group APP
    ../source/config/: app.c
  group APP/config
    ../source/config/: app_cfg.h app_type.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h stm32f10x_conf.h
  group APP/task
    ../source/task/: app_dtu_rec.c app_dtu_rec.h app_dtu_send.c app_dtu_send.h app_mtr_com.c app_mtr_com.h app_task_com.c app_task_measure.c app_task_osal.c app_task_osal_disp.c app_task_osal_led.c APP_task_osal_store.c app_task_osal_tmr.c tasks.h
  group APP/user
    ../source/user/: app_com_type.h app_ModbusInit.c app_var.c CrcCheck.c CrcCheck.h csnr_package_deal.c csnr_package_deal.h hook.c hook.h IAP_program_mcu.c IAP_program_mcu.h RecDataTypeDef.h
  group BSP
    ../source/Software/EvalBoards/Micrium/uC-Eval-STM32F107/BSP/: bsp.c bsp.h bsp_int.c bsp_periph.c core_cm3.c
    ../source/Software/EvalBoards/Micrium/uC-Eval-STM32F107/BSP/IAR/: cstartup.c STM32_FLASH.icf STM32_FLASH_app_realse.icf
  group BSP/driver
    ../source/driver/: bsp_DM412.c bsp_DM412.h bsp_flash.c bsp_flash.h bsp_FRAM.c bsp_FRAM.h bsp_IIC.c bsp_IIC.h bsp_IIC_2.c bsp_IIC_2.h bsp_max7219.c bsp_max7219.h bsp_time.c bsp_time.h bsp_wdt.c bsp_wdt.h drives.h DS3231.c ds3231.h MX25.c mx25.h
  group BSP/OS
    ../source/Software/EvalBoards/Micrium/uC-Eval-STM32F107/BSP/OS/uCOS-III/: bsp_os.c bsp_os.h
  group BSP/ST/STM32/inc
    ../source/Software/EvalBoards/Micrium/uC-Eval-STM32F107/BSP/ST/STM32/inc/: cortexm3_macro.h cortexm3_macro.s stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_lib.h stm32f10x_map.h stm32f10x_nvic.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_systick.h stm32f10x_tim.h stm32f10x_type.h stm32f10x_usart.h stm32f10x_wwdg.h
  group BSP/ST/STM32/src
    ../source/Software/EvalBoards/Micrium/uC-Eval-STM32F107/BSP/ST/STM32/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group doc
    ../doc/: readme.md 处理板和检测板通讯协议 工程文件说明.txt 测试指令.txt
  group OSAL/source
    ../source/Software/OSAL/OS/: osal.c osal.h osal_cpu.h osal_event.c osal_event.h osal_memory.c osal_memory.h osal_timer.c osal_timer.h
  group uC/CPU
    ../source/Software/uC-CPU/ARM-Cortex-M3/IAR/: cpu.h cpu_a.asm cpu_c.c
    ../source/Software/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
  group uC/LIB
    ../source/Software/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group uC/LIB/Ports
    ../source/Software/uC-LIB/Ports/ARM-Cortex-M3/IAR/: lib_mem_a.asm
  group uC/MB/cfg
    ../source/Software/uC-MB/Cfg/Template/: mb_app_hooks.c mb_app_hooks.h mb_cfg.h MB_DATA.C
  group uC/MB/os
    ../source/Software/uC-MB/OS/uCOS-III/: MB_OS.C mb_os.h
  group uC/MB/port
    ../source/Software/uC-MB/Ports/STM32/STM32F103/IAR/: MB_BSP.C
  group uC/MB/source
    ../source/Software/uC-MB/Source/: MB.C MB.h MB_DEF.H MB_UTIL.C MBM_CORE.C MBS_CORE.C
  group uC/OS-III/Port
    ../source/Software/uCOS-III/Ports/ARM-Cortex-M3/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group uC/OS-III/Source
    ../source/Software/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
