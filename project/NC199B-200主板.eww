<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\NC199B-200&#x4e3B;&#x677F;.ewp</path>
  </project>
  <batchBuild/>
</workspace>


